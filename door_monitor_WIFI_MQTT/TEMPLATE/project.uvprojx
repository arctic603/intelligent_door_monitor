# Keil uVision project project.uvprojx, settings and files
target TEMPLATE (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE\Device\STM32F407ZE;.\RTE;.\Objects;..\test;.\Includes;.\HARDWARE\Beep;.\HARDWARE\DELAY;.\HARDWARE\EXTI;.\HARDWARE\DHT11;.\HARDWARE\Key;.\HARDWARE\Led;.\HARDWARE\TIM;.\HARDWARE\USART;.\HARDWARE\Led;.\HARDWARE\WDG;.\HARDWARE\RTC;.\HARDWARE\ADC;.\HARDWARE\SPI;.\HARDWARE\RFID;..\TEMPLATE;.\HARDWARE\I2C;.\HARDWARE\OLED;.\HARDWARE\PAJ7620;.\HARDWARE\FLASH;.\HARDWARE\SFM;.\HARDWARE\SG90;.\HARDWARE\WIFI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./Objects/: main.c includes.c
    ./Includes/: Includes.h fputc.h sys.h
  group LED
    ./HARDWARE/Led/: init_led.c init_led.h
  group KEY
    ./HARDWARE/Key/: key.c key.h
  group EXTI
    ./HARDWARE/EXTI/: EXTI.c EXTI.h
  group BEEP
    ./HARDWARE/Beep/: Beep.c beep.h
  group USART
    ./HARDWARE/USART/: init_USART.c init_USART.h
  group DELAY
    ./HARDWARE/DELAY/: delay.c delay.h
  group TIM
    ./HARDWARE/TIM/: Tim_init.c Tim_init.h
  group TEMPRATURE
    ./HARDWARE/DHT11/: DHT11.c DHT11.h
  group WDG
    ./HARDWARE/WDG/: WWDG.c WWDG.h IWDG.c IWDG.h
  group RTC
    ./HARDWARE/RTC/: RTC.h RTC.c
  group FLASH
    ./HARDWARE/FLASH/: flash.c flash.h
  group ADC
    ./HARDWARE/ADC/: ADC.c ADC.h
  group SPI
    ./HARDWARE/SPI/: SPI.c SPI.h
  group RFID
    ./HARDWARE/RFID/: MFRC522.c MFRC522.h
  group I2C
    ./HARDWARE/I2C/: I2C.c I2C.h
  group OLED
    ./HARDWARE/OLED/: bmp.h OLED.c OLED.h
  group PAJ7620
    ./HARDWARE/PAJ7620/: PAJ7620.c PAJ7620.h PAJ7620_cfg.h PAJ7620_iic.h PAJ7620_iic.c
  group SFM
    ./HARDWARE/SFM/: sfm.c sfm.h
  group SG90
    ./HARDWARE/SG90/: sg90.h sg90.c
  group WIFI
    ./HARDWARE/WIFI/: ESP8266.c ESP8266.h ESP8266_mqtt.c ESP8266_mqtt.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DCMI 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
